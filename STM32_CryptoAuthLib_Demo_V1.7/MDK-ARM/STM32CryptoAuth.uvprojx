# Keil uVision project STM32CryptoAuth.uvprojx, settings and files
target debug (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOD8_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,I2C_HAL
  c include: ..\CryptoAuthLib;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Core;..\Drivers\CMSIS\Core\Include;..\CryptoAuthLib\hal;..\Drivers\ECC_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: main.c stm32f1xx_it.c
  group Drivers
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_gpio.c stm32f1xx_ll_usart.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
    ../Drivers/: system_stm32f1xx.c startup_stm32f103xb.s
  group CryptoAuthLib
    ../CryptoAuthLib/: mse_basic.c mse_debug.c mse_device.c mse_helpers.c mse_iface.c mse_utils_sizes.c
    ../CryptoAuthLib/calib/: calib_aes.c calib_aes_gcm.c calib_basic.c calib_checkmac.c calib_command.c calib_counter.c calib_derivekey.c calib_ecdh.c calib_execution.c calib_gendig.c calib_genkey.c calib_helpers.c calib_hmac.c calib_info.c calib_kdf.c calib_lock.c calib_mac.c calib_nonce.c calib_privwrite.c calib_random.c calib_read.c calib_secureboot.c calib_selftest.c calib_sha.c calib_sign.c calib_updateextra.c calib_verify.c calib_write.c
    ../CryptoAuthLib/crypto/: mse_crypto_sw_sha2.c
    ../CryptoAuthLib/crypto/hashes/: sha2_routines.c
    ../CryptoAuthLib/hal/: mse_hal.c
    ../CryptoAuthLib/host/: mse_host.c
  group ECC_Driver
    ../Drivers/ECC_Driver/: usart.c hal_i2c_bitbang.c i2c_bitbang_stm32.c ecc_i2c.c
target io-debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOD8_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,I2C_EMUL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
